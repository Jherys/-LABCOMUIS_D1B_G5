options:
  parameters:
    author: Natalia Moreno - Jherys Vega
    generate_options: qt_gui
    id: Punto1b
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: D1
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '25'
  states: {}
- name: D2
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: D3
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '75'
  states: {}
- name: D4
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: W
  id: variable_qtgui_range
  parameters:
    label: ancho de pulso
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '25'
  states: {}
- name: fs
  id: variable
  parameters:
    value: samp_rate/100
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: Punto1_0
  id: Punto1
  parameters:
    d: W
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: Punto1_0_0
  id: Punto1
  parameters:
    d: W
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: Punto1_0_1
  id: Punto1
  parameters:
    d: W
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: Punto1_0_2
  id: Punto1
  parameters:
    d: W
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: Punto1_0_3
  id: Punto1
  parameters:
    d: W
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fs/10
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fs/10
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fs/10
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: analog_sig_source_x_2_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fs/10
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: D1
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: D4
    type: float
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: D2
    type: float
  states: {}
- name: blocks_delay_2
  id: blocks_delay
  parameters:
    delay: D3
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [Punto1_0, '0', blocks_add_xx_0, '0']
- [Punto1_0, '0', qtgui_time_sink_x_0, '0']
- [Punto1_0_0, '0', blocks_delay_0, '0']
- [Punto1_0_1, '0', blocks_delay_2, '0']
- [Punto1_0_2, '0', blocks_delay_1, '0']
- [Punto1_0_3, '0', qtgui_time_sink_x_0_0, '1']
- [analog_sig_source_x_0, '0', Punto1_0, '0']
- [analog_sig_source_x_1, '0', Punto1_0_0, '0']
- [analog_sig_source_x_2, '0', Punto1_0_2, '0']
- [analog_sig_source_x_2_0, '0', Punto1_0_1, '0']
- [blocks_add_xx_0, '0', blocks_delay_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_delay_0, '0', blocks_add_xx_0, '1']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_0_0, '0', Punto1_0_3, '0']
- [blocks_delay_1, '0', blocks_add_xx_0, '2']
- [blocks_delay_1, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_2, '0', blocks_add_xx_0, '3']
- [blocks_delay_2, '0', qtgui_time_sink_x_0, '3']

metadata:
  file_format: 1
