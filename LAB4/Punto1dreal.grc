options:
  parameters:
    generate_options: qt_gui
    id: Punto2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: AC
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '0.000001'
    stop: '1'
    value: '1'
  states: {}
- name: AM
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '0.000001'
    stop: '1'
    value: '1'
  states: {}
- name: FM
  id: variable_qtgui_range
  parameters:
    label: Frecuencia mensaje
    start: '1000'
    step: '100'
    stop: '20000'
    value: '1000'
  states: {}
- name: Kp
  id: variable_qtgui_range
  parameters:
    label: Coeficiente Kp
    start: '0'
    step: '0.000001'
    stop: '10'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: EnvolventecomplejaD1B_1
  id: EnvolventecomplejaD1B
  parameters:
    AC: '0.100'
    Kp: Kp
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: AM
    freq: FM
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [EnvolventecomplejaD1B_1, '0', qtgui_freq_sink_x_0, '0']
- [EnvolventecomplejaD1B_1, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', EnvolventecomplejaD1B_1, '0']

metadata:
  file_format: 1
