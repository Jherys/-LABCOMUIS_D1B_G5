options:
  parameters:
    author: uis-e3t
    generate_options: qt_gui
    id: punto3baa
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: AC
  id: variable_qtgui_range
  parameters:
    label: Amplitud PORTADORA
    orient: Qt.Horizontal
    start: '0'
    step: '0.000100'
    stop: '1'
    value: '0.2'
  states: {}
- name: AC_2
  id: variable_qtgui_range
  parameters:
    label: Amplitud PORTADORA
    orient: Qt.Horizontal
    start: '0'
    step: '0.000100'
    stop: '1'
    value: '0.2'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del TX
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Amplitud PORTADORA
    orient: Qt.Horizontal
    start: '0'
    step: '0.000100'
    stop: '1'
    value: '50000000'
  states: {}
- name: ka
  id: variable_qtgui_range
  parameters:
    label: ka
    orient: Qt.Horizontal
    start: '0'
    step: '0.000100'
    stop: '4'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: CalculoPotenciaComunicaciones_0
  id: CalculoPotenciaComunicaciones
  parameters:
    l_vector: '1024'
  states: {}
- name: Modulos_D1B5_0
  id: Modulos_D1B5
  parameters:
    Ac: AC
    ka: ka
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: fc
    dev_args: '""'
    gain0: GTX
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [Modulos_D1B5_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', CalculoPotenciaComunicaciones_0, '0']
- [analog_sig_source_x_0, '0', Modulos_D1B5_0, '0']

metadata:
  file_format: 1
